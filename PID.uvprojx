# Keil uVision project PID.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PID
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --C99
  c include: C:\ti\TivaWare_C_Series-2.1.4.178;C:\Keil_v5;.\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group Source Group 1
    ../../MiniProyecto/Programacion/QEI/: startup_rvmdk.S
    ./: main.c timer1lib.c timer0lib.c uartlib.c pwmlib.c pidlib.c
    C:/ti/TivaWare_C_Series-2.1.4.178/utils/: uartstdio.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0
